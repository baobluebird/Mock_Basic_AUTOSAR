# Keil uVision project OsekOsECU1.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OsekOSECU1
  c flags: Optim=2 uC99=1 uGnu=1 v6Lang=1 v6LangP=3
  c include: ..\oil;..\OsekLib;..\ECU1_VehicleSpeed\ASW;..\ECU1_VehicleSpeed\BSW\ECU_Abstraction\ComHwAbstraction;..\ECU1_VehicleSpeed\BSW\ECU_Abstraction\IoHwAbstraction;..\ECU1_VehicleSpeed\BSW\ECU_Abstraction\MemIf;..\ECU1_VehicleSpeed\BSW\OS;..\ECU1_VehicleSpeed\BSW\Services;..\ECU1_VehicleSpeed\BSW\MCAL\CANDriver;..\ECU1_VehicleSpeed\BSW\MCAL\ICUDriver;..\ECU1_VehicleSpeed\Common;..\ECU1_VehicleSpeed\RTE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group ASW
    ../ECU1_VehicleSpeed/ASW/: SpeedSensorSWC.c NVBlockSWC.c
  group RTE
    ../ECU1_VehicleSpeed/RTE/: Rte_Can.c Rte_Dem.c Rte_SpeedSensor.c Rte_Nvm.c
  group Services
    ../ECU1_VehicleSpeed/BSW/Services/: Can.c Dem.c Nvm.c
  group ECU_Abstraction
    ../ECU1_VehicleSpeed/BSW/ECU_Abstraction/ComHwAbstraction/: ComHwAbstraction.c
    ../ECU1_VehicleSpeed/BSW/ECU_Abstraction/IoHwAbstraction/: IoHwAb_SpeedSensor.c
    ../ECU1_VehicleSpeed/BSW/ECU_Abstraction/MemIf/: MemIf.c
  group OS
    ../ECU1_VehicleSpeed/BSW/OS/startup/: keilUvisoin_startup.s
    ../ECU1_VehicleSpeed/BSW/OS/: OsekLib.lib counter.c counter.h hook.c os.h OsCfg.c OsCfg.h OsTypes.h OsekOSECU1.c
  group MCAL
    ../ECU1_VehicleSpeed/BSW/MCAL/CANDriver/: Can_Driver.c
    ../ECU1_VehicleSpeed/BSW/MCAL/ICUDriver/: Icu_Driver.c
software components: CMSIS:CORE 6.1.0
